<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Insole_right_kw.ewp</path>
  </project>
  <batchBuild />
</workspace>
